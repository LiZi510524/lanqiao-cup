# Keil uVision project Led.uvproj, settings and files
target User (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Led
    ./: main.c
