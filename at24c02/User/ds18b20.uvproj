# Keil uVision project ds18b20.uvproj, settings and files
target User (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group AT24C02
    ../../ds1302/User/: main.c hardware.c
    ./: onewire.c iic.c
