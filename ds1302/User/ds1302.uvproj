# Keil uVision project ds1302.uvproj, settings and files
target ds1302 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: hardware.c main.c
    E:/: ds1302.c
